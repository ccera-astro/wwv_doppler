options:
  parameters:
    generate_options: no_gui
    id: wwv_doppler
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: det_srate
  id: variable
  parameters:
    comment: Final detector sample rate
    value: '500'
  states: {}
- name: deviation
  id: variable
  parameters:
    comment: Max expected carrier deviation
    value: '10'
  states: {}
- name: first_len
  id: variable
  parameters:
    value: len(first_taps)
  states: {}
- name: first_taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: The taps for the filter above
    cutoff_freq: 100e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 50e3
    win: firdes.WIN_HAMMING
  states: {}
- name: high_rate
  id: variable
  parameters:
    comment: 1st stage decimator output rate
    value: '250000'
  states: {}
- name: mid_rate
  id: variable
  parameters:
    comment: 2nd stage decimator output rate
    value: '5000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: second_len
  id: variable
  parameters:
    value: len(second_taps)
  states: {}
- name: second_taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: The taps for the filter above
    cutoff_freq: '2000'
    gain: '5.0'
    samp_rate: high_rate
    width: '1200'
    win: firdes.WIN_HAMMING
  states: {}
- name: third_len
  id: variable
  parameters:
    value: len(third_taps)
  states: {}
- name: third_taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: The taps for the filter above
    cutoff_freq: '200'
    gain: '5.0'
    samp_rate: mid_rate
    width: '20'
    win: firdes.WIN_HAMMING
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: deviation/(det_srate/2.0)*3.14159
    min_freq: deviation/(det_srate/2.0)*3.14159
    w: 3.14159/100
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/(2*3.14159)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: det_srate
    type: float
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device string
    type: str
    value: '"airspy=0"'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: int(high_rate/mid_rate)
    taps: second_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: int(mid_rate/det_srate)
    taps: third_taps
    type: ccc
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 920e6
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: offset
    comment: |-
      Rotate down to baseband--the hardware is
      tuned 'offset' low, to avoid any DC offset
      Then this rotates and filters so that
      desired signal is in the middle of the passband
    decim: int(samp_rate/high_rate)
    samp_rate: samp_rate
    taps: first_taps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import sys
  states: {}
- name: logtime
  id: parameter
  parameters:
    label: Logging interval
    type: intx
    value: '5'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      We use a 3-stage filter to reduce CPU load
      The 1st stage is fairly "light"
      With the fine filtering ocurring at the last stage.
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      **** NB *******************************
      These parameters are just best guesses
      as to what might work
      experimentation IS A MUST!!
      ***************************************
  states: {}
- name: offset
  id: parameter
  parameters:
    label: Frequency Offset
    type: eng_float
    value: 2e4
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: device
    bb_gain0: '20'
    freq0: freq-offset
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: Log file name prefix
    type: str
    value: '"wwv-10MHz-"'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '40'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(det_srate*2.0)
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_rf
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered_rf
  states: {}
- name: wwv_logger
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time



      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Log WWV doppler data"""

          def __init__(self, log_rate=1.0, prefix="./", samp_rate=1e3):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='WWV data Logger',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.log_rate = log_rate
              self.prefix = prefix
              self.avg = 0.0
              self.now = time.time()
              self.count = 0
              self.samp_rate = samp_rate

          def work(self, input_items, output_items):
              """Log at defined rate"""
              
              for v in input_items[0]:
                  self.avg += v
                  self.count += 1
                  if (self.count >= (self.log_rate * self.samp_rate)):
                      self.avg /= self.count
                      self.count = 0
                      ltp = time.gmtime()
                      d = "%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
                      fn = self.prefix + d + ".csv"
                      fp = open(fn, "a")
                      fp.write("%02d,%02d,%02d,%f\n" % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec, self.avg))
                  
        
              return len(input_items[0])
    log_rate: logtime
    prefix: prefix
    samp_rate: det_srate
  states: {}

connections:
- [analog_pll_freqdet_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', single_pole_iir_filter_xx_0, '0']
- [fft_filter_xxx_0, '0', fft_filter_xxx_0_0, '0']
- [fft_filter_xxx_0_0, '0', virtual_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', fft_filter_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [single_pole_iir_filter_xx_0, '0', wwv_logger, '0']
- [virtual_source_0, '0', analog_pll_freqdet_cf_0, '0']

metadata:
  file_format: 1
