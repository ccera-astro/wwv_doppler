options:
  parameters:
    generate_options: no_gui
    id: wwv_doppler
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: det_srate
  id: variable
  parameters:
    comment: 2nd stage decimator output rate
    value: '500'
  states: {}
- name: fc
  id: variable
  parameters:
    value: (f1+f2)/2.0
  states: {}
- name: fftsize
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: first_len
  id: variable
  parameters:
    value: len(first_taps)
  states: {}
- name: first_taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: The taps for the filter above
    cutoff_freq: 100e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 50e3
    win: firdes.WIN_HAMMING
  states: {}
- name: high_rate
  id: variable
  parameters:
    comment: 1st stage decimator output rate
    value: '250000'
  states: {}
- name: mid_rate
  id: variable
  parameters:
    comment: 2nd stage decimator output rate
    value: '5000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: second_len
  id: variable
  parameters:
    value: len(second_taps)
  states: {}
- name: second_taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: The taps for the filter above
    cutoff_freq: '2000'
    gain: '1.0'
    samp_rate: high_rate
    width: '1200'
    win: firdes.WIN_HAMMING
  states: {}
- name: third_len
  id: variable
  parameters:
    value: len(third_taps)
  states: {}
- name: third_taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: The taps for the filter above
    cutoff_freq: '200'
    gain: '1.0'
    samp_rate: mid_rate
    width: '20'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '1000.0'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '1000.0'
    type: float
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device string
    type: str
    value: '"airspy=0"'
  states: {}
- name: f1
  id: parameter
  parameters:
    label: Frequency 1
    type: eng_float
    value: 400.0e6
  states: {}
- name: f2
  id: parameter
  parameters:
    label: Frequency 2
    type: eng_float
    value: 405e6
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: int(high_rate/mid_rate)
    taps: second_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: int(mid_rate/det_srate)
    taps: third_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: int(mid_rate/det_srate)
    taps: third_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_1
  id: fft_filter_xxx
  parameters:
    decim: int(high_rate/mid_rate)
    taps: second_taps
    type: ccc
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: f1-fc
    comment: |-
      Rotate down to baseband--the hardware is
      tuned 'offset' low, to avoid any DC offset
      Then this rotates and filters so that
      desired signal is in the middle of the passband
    decim: int(samp_rate/high_rate)
    samp_rate: samp_rate
    taps: first_taps
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: f2-fc
    comment: |-
      Rotate down to baseband--the hardware is
      tuned 'offset' low, to avoid any DC offset
      Then this rotates and filters so that
      desired signal is in the middle of the passband
    decim: int(samp_rate/high_rate)
    samp_rate: samp_rate
    taps: first_taps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import sys
  states: {}
- name: logtime
  id: parameter
  parameters:
    label: Logging interval
    type: intx
    value: '10'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      We use a 3-stage filter to reduce CPU load
      The 1st stage is fairly "light"
      With the fine filtering ocurring at the last stage.
  states: {}
- name: offset
  id: parameter
  parameters:
    label: Frequency Offset
    type: eng_float
    value: 2e4
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: device
    bb_gain0: '20'
    clock_source0: internal
    freq0: fc
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: Log file name prefix
    type: str
    value: '"wwv-10MHz-"'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '40'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.1'
    type: float
    vlen: fftsize
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.1'
    type: float
    vlen: fftsize
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_rf1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: filtered_rf2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered_rf1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: filtered_rf2
  states: {}
- name: wwv_logger
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time



      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Log WWV doppler data"""

          def __init__(self, log_rate=1.0, prefix="./", samp_rate=1e3, fftsize=2048):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='WWV data Logger',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.log_rate = log_rate
              self.prefix = prefix
              self.avg = 0.0
              self.now = time.time()
              self.count = 0
              self.samp_rate = samp_rate
              self.fftsize = fftsize

          def work(self, input_items, output_items):
              """Log at defined rate"""
              
              for v in input_items[0]:
                  mx = np.argmax(v)
                  mxf = mx - self.fftsize/2
                  mxf *= (self.samp_rate/self.fftsize)
                  self.avg += mxf
                  self.count += 1
                  if ((time.time()) - self.now >= self.log_rate):
                      ltp = time.gmtime()
                      d = "%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
                      self.avg /= self.count
                      fn = self.prefix + d + ".csv"
                      fp = open(fn, "a")
                      fp.write ("%02d,%02d,%0d,%f\n" % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec, self.avg))
                      self.avg = 0
                      self.count = 0
                      self.now = time.time()
                  
        
              return len(input_items[0])
    fftsize: fftsize
    log_rate: logtime
    prefix: prefix+"-0-"
    samp_rate: det_srate
  states: {}
- name: wwv_logger_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time



      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Log WWV doppler data"""

          def __init__(self, log_rate=1.0, prefix="./", samp_rate=1e3, fftsize=2048):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='WWV data Logger',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.log_rate = log_rate
              self.prefix = prefix
              self.avg = 0.0
              self.now = time.time()
              self.count = 0
              self.samp_rate = samp_rate
              self.fftsize = fftsize

          def work(self, input_items, output_items):
              """Log at defined rate"""
              
              for v in input_items[0]:
                  mx = np.argmax(v)
                  mxf = mx - self.fftsize/2
                  mxf *= (self.samp_rate/self.fftsize)
                  self.avg += mxf
                  self.count += 1
                  if ((time.time()) - self.now >= self.log_rate):
                      ltp = time.gmtime()
                      d = "%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
                      self.avg /= self.count
                      fn = self.prefix + d + ".csv"
                      fp = open(fn, "a")
                      fp.write ("%02d,%02d,%0d,%f\n" % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec, self.avg))
                      self.avg = 0
                      self.count = 0
                      self.now = time.time()
                  
        
              return len(input_items[0])
    fftsize: fftsize
    log_rate: logtime
    prefix: prefix+"-1-"
    samp_rate: det_srate
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_multiply_const_xx_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_multiply_const_xx_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_filter_xxx_0, '0', fft_filter_xxx_0_0, '0']
- [fft_filter_xxx_0_0, '0', virtual_sink_0, '0']
- [fft_filter_xxx_0_0_0, '0', virtual_sink_0_0, '0']
- [fft_filter_xxx_0_1, '0', fft_filter_xxx_0_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', fft_filter_xxx_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', fft_filter_xxx_0_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', wwv_logger, '0']
- [single_pole_iir_filter_xx_0_0, '0', wwv_logger_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
