options:
  parameters:
    generate_options: no_gui
    id: wwv_doppler
    output_language: python
    run_options: run
    title: WWV Doppler Measurement
  states: {}

blocks:
- name: farray
  id: variable
  parameters:
    value: '[f1,f2]'
  states: {}
- name: fc
  id: variable
  parameters:
    comment: Actual tuned center frequency
    value: (uf1+uf2)/2.0
  states: {}
- name: first_len
  id: variable
  parameters:
    value: len(first_taps)
  states: {}
- name: first_taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: The taps for the filter above
    cutoff_freq: 100e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 90e3
    win: firdes.WIN_HAMMING
  states: {}
- name: high_rate
  id: variable
  parameters:
    comment: 1st stage decimator output rate
    value: '250000'
  states: {}
- name: mid_rate
  id: variable
  parameters:
    comment: 2nd stage decimator output rate
    value: '2500'
  states: {}
- name: par_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: pll_limit
  id: variable
  parameters:
    value: (7.5/(mid_rate/2.0))*math.pi
  states: {}
- name: pll_loop
  id: variable
  parameters:
    value: math.pi/150
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: second_len
  id: variable
  parameters:
    value: len(second_taps)
  states: {}
- name: second_taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: The taps for the filter above
    cutoff_freq: mid_rate/2.2
    gain: '1.0'
    samp_rate: high_rate
    width: '3500'
    win: firdes.WIN_HAMMING
  states: {}
- name: snr_fft_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: snr_out1
  id: variable_function_probe
  parameters:
    block_id: snr_probe1
    function_name: level
    poll_rate: '5'
    value: '1.0'
  states: {}
- name: snr_out2
  id: variable_function_probe
  parameters:
    block_id: snr_probe2
    function_name: level
    poll_rate: '5'
    value: '1.0'
  states: {}
- name: third_len
  id: variable
  parameters:
    value: len(third_taps)
  states: {}
- name: third_taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: The taps for the filter above
    cutoff_freq: '725'
    gain: '1.0'
    samp_rate: mid_rate
    width: '35'
    win: firdes.WIN_HAMMING
  states: {}
- name: tp_out1
  id: variable_function_probe
  parameters:
    block_id: tp_probe1
    function_name: level
    poll_rate: '5'
    value: '0.0'
  states: {}
- name: tp_out2
  id: variable_function_probe
  parameters:
    block_id: tp_probe2
    function_name: level
    poll_rate: '5'
    value: '0.0'
  states: {}
- name: uf1
  id: variable
  parameters:
    value: farray[0]+upvf
  states: {}
- name: uf2
  id: variable
  parameters:
    value: farray[1]+upvf
  states: {}
- name: upv
  id: variable
  parameters:
    value: 120e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: pll_limit
    min_freq: '-pll_limit'
    w: math.pi/100
  states: {}
- name: analog_pll_refout_cc_0_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: pll_limit
    min_freq: '-pll_limit'
    w: math.pi/100
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: ((1.0/(math.pi*2.0))*mid_rate)*(1.0/farray[0])*1.0e9
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: ((1.0/(math.pi*2.0))*mid_rate)*(1.0/farray[1])*1.0e9
  states: {}
- name: bist
  id: parameter
  parameters:
    label: BIST on/off
    type: eng_float
    value: '0.0'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: snr_fft_size
  states: {}
- name: blocks_complex_to_mag_squared_1_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: snr_fft_size
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: par_decim
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: par_decim
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_1
  id: blocks_keep_one_in_n
  parameters:
    n: par_decim
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_1_0
  id: blocks_keep_one_in_n
  parameters:
    n: par_decim
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: snr_fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: snr_fft_size
    type: complex
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device string
    type: str
    value: '"airspy=0,linearity=1,bias=1"'
  states: {}
- name: f1
  id: parameter
  parameters:
    label: Frequency 1
    type: eng_float
    value: 15e6
  states: {}
- name: f2
  id: parameter
  parameters:
    label: Frequency 2
    type: eng_float
    value: 20e6
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: int(high_rate/mid_rate)
    taps: second_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: third_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: third_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_1
  id: fft_filter_xxx
  parameters:
    decim: int(high_rate/mid_rate)
    taps: second_taps
    type: ccc
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: snr_fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(snr_fft_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: snr_fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(snr_fft_size)
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: uf1-fc
    comment: |-
      RF tuning is arranged to sit
      exactly half-way between
      F1 and F2
      This rotates F1 to baseband
    decim: int(samp_rate/high_rate)
    samp_rate: samp_rate
    taps: first_taps
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: uf2-fc
    comment: |-
      F tuning is arranged to sit
      exactly half-way between
      F1 and F2
      This rotates F2 to baseband
    decim: int(samp_rate/high_rate)
    samp_rate: samp_rate
    taps: first_taps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import sys
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: logtime
  id: parameter
  parameters:
    label: Logging interval
    type: intx
    value: '2'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      We use a 3-stage filter to reduce CPU load
      The 1st stage is fairly "light"
      With the fine filtering ocurring at the last stage.
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Set 'gain' to produce frequency estimate,
      in Hz, on the output.
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      A low pass filter
      gives an estimate of the
      fixed frequency offset component
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: device
    bb_gain0: '20'
    clock_source0: internal
    freq0: fc
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: Log file name prefix
    type: str
    value: '"wwv-"'
  states: {}
- name: purge
  id: parameter
  parameters:
    label: Purge time (days)
    type: eng_float
    value: '5.0'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '40'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(mid_rate*10)
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(mid_rate*10)
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(mid_rate*10)
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_1_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(mid_rate*10)
    type: float
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/20.0
    type: float
    vlen: snr_fft_size
  states: {}
- name: single_pole_iir_filter_xx_1_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/20.0
    type: float
    vlen: snr_fft_size
  states: {}
- name: snr_estimator_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def tone_pwr(self,tone,fft,srate):
              mid = len(fft)/2
              mid = int(mid)
              bw = srate/len(fft)
              off = float(abs(tone))/float(bw)
              off = int(off)
              
              if (tone >= 0):
                  st = mid+(off-1)
                  end = st+3
              else:
                  st = mid-(off+1)
                  end = st+3
              
              pwr = np.mean(fft[st:end])
              return pwr

          def __init__(self, fftsize=512,srate=2500):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='FFT-based SNR estimator',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=[np.float32,np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fftsize = fftsize
              self.srate = srate
              self.tpcount = 0

          def work(self, input_items, output_items):
              """Extract SNR estimate"""
              fs = self.fftsize
              pace = float(self.srate) / float(self.fftsize)
              #
              # Determine bin size in Hz
              #
              binsize = float(self.srate) / float(self.fftsize)
              
              #
              # Determine which offset-from-middle is 100Hz
              # WWV has a 100Hz spectral artifact from the
              # 100Hz sub-carrer
              #
              hhz = int(100.0/binsize)
              
              #
              # Determine offset of 500Hz tone
              #
              fhhz = int(500.0/binsize)
              
              #
              # Determine offset of 600Hz tone
              #
              shhz = int(600.0/binsize)
              
              for x in range(len(output_items[0])):
                  v = input_items[0][x]
                  mid = int(self.fftsize/2)
                  #
                  # Centre frequency
                  #
                  signal = self.tone_pwr(0.0,v,self.srate)
                  
                  #
                  # Noise components
                  #
                  n1 = self.tone_pwr(25.0,v,self.srate)
                  n2  = self.tone_pwr(-25.0,v,self.srate)
                  na = (n1+n2)/2.0
                  
                  #
                  # 100Hz sub-carrer
                  #
                  hh = self.tone_pwr(100.0,v,self.srate)
                  hh += self.tone_pwr(-100.0,v,self.srate)
                  hh /= 2.0
                  
                  #
                  # 500Hz tone
                  #
                  s500 = self.tone_pwr(500.0,v,self.srate)
                  s500 += self.tone_pwr(-500.0,v,self.srate)
                  s500 /= 2.0
                  
                  #
                  # 600Hz tone
                  #
                  s600 = self.tone_pwr(600.0,v,self.srate)
                  s600 += self.tone_pwr(-600.0,v,self.srate)
                  s600 /= 2.0
                  
                  #
                  # 440Hz tone
                  #
                  s440 = self.tone_pwr(440.0,v,self.srate)
                  s440 += self.tone_pwr(-440.0,v,self.srate)
                  s440 /= 2.0
                  
                  #
                  # Pick loudest tone from 440,500,600
                  #
                  stone = max([s500,s600,s440])
                  

                  #
                  # Carrier/Noise (SNR-ish) estimate
                  #
                  snr = signal/na
                  
                  #
                  # Tones-present flag
                  #
                  # If the loudest tone is at least 5 times the boise AND
                  #   the 100Hz tone is also at least 5 times the noise
                  #
                  #
                  if (stone/na > 3.5 and hh/na > 3.5):
                      self.tpcount = int(pace*15)
                  else:
                      self.tpcount -= 1

                  output_items[0][x] = snr
                  output_items[1][x] = 1 if self.tpcount > 0 else 0
              return len(output_items[0])
    fftsize: '512'
    srate: mid_rate
  states: {}
- name: snr_estimator_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def tone_pwr(self,tone,fft,srate):
              mid = len(fft)/2
              mid = int(mid)
              bw = srate/len(fft)
              off = float(abs(tone))/float(bw)
              off = int(off)
              
              if (tone >= 0):
                  st = mid+(off-1)
                  end = st+3
              else:
                  st = mid-(off+1)
                  end = st+3
              
              pwr = np.mean(fft[st:end])
              return pwr

          def __init__(self, fftsize=512,srate=2500):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='FFT-based SNR estimator',   # will show up in GRC
                  in_sig=[(np.float32,fftsize)],
                  out_sig=[np.float32,np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fftsize = fftsize
              self.srate = srate
              self.tpcount = 0

          def work(self, input_items, output_items):
              """Extract SNR estimate"""
              fs = self.fftsize
              pace = float(self.srate) / float(self.fftsize)
              #
              # Determine bin size in Hz
              #
              binsize = float(self.srate) / float(self.fftsize)
              
              #
              # Determine which offset-from-middle is 100Hz
              # WWV has a 100Hz spectral artifact from the
              # 100Hz sub-carrer
              #
              hhz = int(100.0/binsize)
              
              #
              # Determine offset of 500Hz tone
              #
              fhhz = int(500.0/binsize)
              
              #
              # Determine offset of 600Hz tone
              #
              shhz = int(600.0/binsize)
              
              for x in range(len(output_items[0])):
                  v = input_items[0][x]
                  mid = int(self.fftsize/2)
                  #
                  # Centre frequency
                  #
                  signal = self.tone_pwr(0.0,v,self.srate)
                  
                  #
                  # Noise components
                  #
                  n1 = self.tone_pwr(25.0,v,self.srate)
                  n2  = self.tone_pwr(-25.0,v,self.srate)
                  na = (n1+n2)/2.0
                  
                  #
                  # 100Hz sub-carrer
                  #
                  hh = self.tone_pwr(100.0,v,self.srate)
                  hh += self.tone_pwr(-100.0,v,self.srate)
                  hh /= 2.0
                  
                  #
                  # 500Hz tone
                  #
                  s500 = self.tone_pwr(500.0,v,self.srate)
                  s500 += self.tone_pwr(-500.0,v,self.srate)
                  s500 /= 2.0
                  
                  #
                  # 600Hz tone
                  #
                  s600 = self.tone_pwr(600.0,v,self.srate)
                  s600 += self.tone_pwr(-600.0,v,self.srate)
                  s600 /= 2.0
                  
                  #
                  # 440Hz tone
                  #
                  s440 = self.tone_pwr(440.0,v,self.srate)
                  s440 += self.tone_pwr(-440.0,v,self.srate)
                  s440 /= 2.0
                  
                  #
                  # Pick loudest tone from 440,500,600
                  #
                  stone = max([s500,s600,s440])
                  

                  #
                  # Carrier/Noise (SNR-ish) estimate
                  #
                  snr = signal/na
                  
                  #
                  # Tones-present flag
                  #
                  # If the loudest tone is at least 5 times the boise AND
                  #   the 100Hz tone is also at least 5 times the noise
                  #
                  #
                  if (stone/na > 3.5 and hh/na > 3.5):
                      self.tpcount = int(pace*15)
                  else:
                      self.tpcount -= 1

                  output_items[0][x] = snr
                  output_items[1][x] = 1 if self.tpcount > 0 else 0
              return len(output_items[0])
    fftsize: '512'
    srate: mid_rate
  states: {}
- name: snr_probe1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: snr_probe2
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: tp_probe1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: tp_probe2
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: upvf
  id: parameter
  parameters:
    label: Upconverter conversion frequency
    type: eng_float
    value: 120e6
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_rf1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: filtered_rf2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered_rf1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: filtered_rf2
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: filtered_rf1
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: filtered_rf2
  states: {}
- name: wwv_doplog_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport glob\nimport os\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Doppler Logger\"\"\"\n\n    def __init__(self, prefix=\"./\", lograte=10.0, srate=1000, snr=1.0,tp=0.0,purge=5.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='WWV Doppler Logger',   # will show up in GRC\n            in_sig=[np.float32]*2,\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.prefix = prefix\n        self.lograte = lograte\n        self.avg = 0.0\n        self.pavg = 0.0\n        self.acnt = 0\n        self.now = time.time()\n        self.srate = srate\n        self.snr = 1.0\n        self.snravg = 1.0\n        self.cursnr = 1.0\n        self.snrcnt = 0\n        self.tp = 0.0\n        self.lastpurge = self.now\n        self.DAY = 86400\n        self.purge = purge\n\n    def work(self, input_items, output_items):\n        \"\"\"Log frequency offsets\"\"\"\n        if (self.cursnr != self.snr):\n            self.cursnr = self.snr\n            self.snravg += self.snr\n            self.snrcnt += 1\n        for x in range(len(input_items[0])):\n            self.avg += input_items[0][x]\n            self.pavg += input_items[1][x]\n            self.acnt += 1\n            if (self.acnt >= (self.srate * self.lograte)):\n                self.avg /= self.acnt\n                self.pavg /= self.acnt\n                self.acnt = 0\n                ltp = time.gmtime()\n                d = \"%04d%02d%02d\" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)\n                fn = self.prefix + d + \".csv\"\n                fp = open(fn, \"a\")\n                db = np.log10(self.pavg+1.0e-14)*10.0\n                if (self.snrcnt != 0):\n                    snra = self.snravg / self.snrcnt\n                    self.snrcnt = 0\n                    self.snravg = 0.0\n                else:\n                    snra = self.snr\n                snra = np.log10(snra+1.0e-14)*10.0\n                fp.write (\"%02d,%02d,%02d,%f,%f,%f,%f\\n\" % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec, self.avg,db,snra,self.tp))\n                fp.close()\n                self.avg = 0\n                self.pavg = 0\n\n                #\n                # Time to purge old data\n                #\n                if ((time.time() - self.lastpurge) > (self.DAY/24)):\n                    fl = glob.glob(self.prefix+\"*.csv\")\n                    self.lastpurge = time.time()\n                    for f in fl:\n                        sts = os.stat(f)\n                        if ((time.time() - sts.st_mtime) > (self.purge * self.DAY)):\n                            os.remove(f)\n  \n            \n        \n        return len(input_items[0])\n\n"
    lograte: logtime
    prefix: prefix+"%-.2fMHz-" % (farray[0]/1.0e6)
    purge: purge
    snr: snr_out1
    srate: mid_rate/par_decim
    tp: tp_out1
  states: {}
- name: wwv_doplog_2
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport glob\nimport os\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Doppler Logger\"\"\"\n\n    def __init__(self, prefix=\"./\", lograte=10.0, srate=1000, snr=1.0,tp=0.0,purge=5.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='WWV Doppler Logger',   # will show up in GRC\n            in_sig=[np.float32]*2,\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.prefix = prefix\n        self.lograte = lograte\n        self.avg = 0.0\n        self.pavg = 0.0\n        self.acnt = 0\n        self.now = time.time()\n        self.srate = srate\n        self.snr = 1.0\n        self.snravg = 1.0\n        self.cursnr = 1.0\n        self.snrcnt = 0\n        self.tp = 0.0\n        self.lastpurge = self.now\n        self.DAY = 86400\n        self.purge = purge\n\n    def work(self, input_items, output_items):\n        \"\"\"Log frequency offsets\"\"\"\n        if (self.cursnr != self.snr):\n            self.cursnr = self.snr\n            self.snravg += self.snr\n            self.snrcnt += 1\n        for x in range(len(input_items[0])):\n            self.avg += input_items[0][x]\n            self.pavg += input_items[1][x]\n            self.acnt += 1\n            if (self.acnt >= (self.srate * self.lograte)):\n                self.avg /= self.acnt\n                self.pavg /= self.acnt\n                self.acnt = 0\n                ltp = time.gmtime()\n                d = \"%04d%02d%02d\" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)\n                fn = self.prefix + d + \".csv\"\n                fp = open(fn, \"a\")\n                db = np.log10(self.pavg+1.0e-14)*10.0\n                if (self.snrcnt != 0):\n                    snra = self.snravg / self.snrcnt\n                    self.snrcnt = 0\n                    self.snravg = 0.0\n                else:\n                    snra = self.snr\n                snra = np.log10(snra+1.0e-14)*10.0\n                fp.write (\"%02d,%02d,%02d,%f,%f,%f,%f\\n\" % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec, self.avg,db,snra,self.tp))\n                fp.close()\n                self.avg = 0\n                self.pavg = 0\n\n                #\n                # Time to purge old data\n                #\n                if ((time.time() - self.lastpurge) > (self.DAY/24)):\n                    fl = glob.glob(self.prefix+\"*.csv\")\n                    self.lastpurge = time.time()\n                    for f in fl:\n                        sts = os.stat(f)\n                        if ((time.time() - sts.st_mtime) > (self.purge * self.DAY)):\n                            os.remove(f)\n  \n            \n        \n        return len(input_items[0])\n\n"
    lograte: logtime
    prefix: prefix+"%-.2fMHz-" % (farray[1]/1.0e6)
    purge: purge
    snr: snr_out2
    srate: mid_rate/par_decim
    tp: tp_out2
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '51015'
  states: {}
- name: zoom
  id: parameter
  parameters:
    label: Zoom factor for frequency offset
    type: eng_float
    value: '1.0'
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_pll_refout_cc_0, '0']
- [analog_agc_xx_0_0, '0', analog_pll_refout_cc_0_0, '0']
- [analog_pll_refout_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_pll_refout_cc_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0_1, '0']
- [blocks_complex_to_mag_squared_0_0, '0', single_pole_iir_filter_xx_0_1_0, '0']
- [blocks_complex_to_mag_squared_1, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_complex_to_mag_squared_1_0, '0', single_pole_iir_filter_xx_1_0, '0']
- [blocks_keep_one_in_n_0, '0', wwv_doplog_1, '0']
- [blocks_keep_one_in_n_0_0, '0', wwv_doplog_1, '1']
- [blocks_keep_one_in_n_0_1, '0', wwv_doplog_2, '0']
- [blocks_keep_one_in_n_0_1_0, '0', wwv_doplog_2, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_filter_xxx_0, '0', fft_filter_xxx_0_0, '0']
- [fft_filter_xxx_0_0, '0', virtual_sink_0, '0']
- [fft_filter_xxx_0_0_0, '0', virtual_sink_0_0, '0']
- [fft_filter_xxx_0_1, '0', fft_filter_xxx_0_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_1_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', fft_filter_xxx_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', fft_filter_xxx_0_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_keep_one_in_n_0_1, '0']
- [single_pole_iir_filter_xx_0_1, '0', blocks_keep_one_in_n_0_0, '0']
- [single_pole_iir_filter_xx_0_1_0, '0', blocks_keep_one_in_n_0_1_0, '0']
- [single_pole_iir_filter_xx_1, '0', snr_estimator_1, '0']
- [single_pole_iir_filter_xx_1_0, '0', snr_estimator_2, '0']
- [snr_estimator_1, '0', snr_probe1, '0']
- [snr_estimator_1, '1', tp_probe1, '0']
- [snr_estimator_2, '0', snr_probe2, '0']
- [snr_estimator_2, '1', tp_probe2, '0']
- [virtual_source_0, '0', analog_agc_xx_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0_0, '0', analog_agc_xx_0_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [virtual_source_0_1, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_1_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
